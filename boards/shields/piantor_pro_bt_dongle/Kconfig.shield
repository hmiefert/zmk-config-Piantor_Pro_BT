## boards/shields/piantor_pro_bt_dongle/Kconfig.shield
```kconfig
config SHIELD_PIANTOR_PRO_BT_DONGLE
    def_bool $(shields_list_contains,piantor_pro_bt_dongle)
```
